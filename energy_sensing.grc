options:
  parameters:
    generate_options: qt_gui
    id: energy_sensing
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_r
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: central_freq
  id: variable
  parameters:
    value: '446006250'
  states: {}
- name: ch_freq
  id: variable
  parameters:
    value: '446006000'
  states: {}
- name: ch_space
  id: variable
  parameters:
    value: 12.5e3
  states: {}
- name: low_pass_tap
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '5000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: r_samp
  id: variable
  parameters:
    value: 480e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.2e6
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '350'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_2_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_3
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '100'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '100'
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '100'
  states: {}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '100'
  states: {}
- name: blocks_nlog10_ff_0_1_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '100'
  states: {}
- name: blocks_nlog10_ff_0_2
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '100'
  states: {}
- name: blocks_nlog10_ff_0_2_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '100'
  states: {}
- name: blocks_nlog10_ff_0_3
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '100'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_3
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: float
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: float
  states: {}
- name: blocks_stream_to_vector_1_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: float
  states: {}
- name: blocks_stream_to_vector_1_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: float
  states: {}
- name: blocks_stream_to_vector_1_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: float
  states: {}
- name: blocks_stream_to_vector_1_2
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: float
  states: {}
- name: blocks_stream_to_vector_1_2_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: float
  states: {}
- name: blocks_stream_to_vector_1_3
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: blocks_threshold_ff_0_0_0
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: blocks_threshold_ff_0_1
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: blocks_threshold_ff_0_1_0
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: blocks_threshold_ff_0_2
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: blocks_threshold_ff_0_2_0
  id: blocks_threshold_ff
  parameters:
    high: '500'
    init: '0'
    low: '500'
  states: {}
- name: blocks_threshold_ff_0_3
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_2_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_3
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import csv


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, file_path="threshold_vector.csv"):  # only default arguments here
              """arguments to this function show up as parameters in GRC""""""[(np.float32, 8)]"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.float32 for i in range(8)],
                  out_sig=None 
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.file_path = file_path
              self.file = open(self.file_path, 'w', newline='')
              self.write = csv.writer(self.file)
              self.file.write("Detection data")

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              """output_items[0] = input_items.flatten()"""
             	data = np.array(input_items)
             	#self.file.write(str(data))
             	np.savetxt("detection_result.csv", data * 100000, delimiter=",")
              return len(input_items[0])
    file_path: '"/home/ngn/ngn_project/detection_result.csv"'
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(2048)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(2048)
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(2048)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(2048)
  states: {}
- name: fft_vxx_0_1_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(2048)
  states: {}
- name: fft_vxx_0_2
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(2048)
  states: {}
- name: fft_vxx_0_2_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(2048)
  states: {}
- name: fft_vxx_0_3
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(2048)
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (1- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (2- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (3- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (7- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (4- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (8- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (6- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (5- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"1"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"2"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"3"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"4"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    name: '"Test"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: ch_freq
    fftsize: '1024'
    name: '"Frequency Sink"'
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"0 T"'
    vlen: '2048'
    x_start: '445000000'
    x_step: '446000000'
    ymax: '3'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"1 T"'
    vlen: '2048'
    x_start: '445000000'
    x_step: '446000000'
    ymax: '3'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"5 T"'
    vlen: '2048'
    x_start: '445000000'
    x_step: '446000000'
    ymax: '3'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_1
  id: qtgui_vector_sink_f
  parameters:
    name: '"2 T"'
    vlen: '2048'
    x_start: '445000000'
    x_step: '446000000'
    ymax: '3'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_1_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"6 T"'
    vlen: '2048'
    x_start: '445000000'
    x_step: '446000000'
    ymax: '3'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_2
  id: qtgui_vector_sink_f
  parameters:
    name: '"3 T"'
    vlen: '2048'
    x_start: '445000000'
    x_step: '446000000'
    ymax: '3'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_2_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"7 T"'
    vlen: '2048'
    x_start: '445000000'
    x_step: '446000000'
    ymax: '3'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_3
  id: qtgui_vector_sink_f
  parameters:
    name: '"4 T"'
    vlen: '2048'
    x_start: '445000000'
    x_step: '446000000'
    ymax: '3'
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: ch_freq
    fftsize: '1024'
    name: '"Waterfall Sink"'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: ch_freq
    gain0: '0.8'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_1, '0', blocks_nlog10_ff_0_1, '0']
- [blocks_complex_to_mag_squared_0_1_0, '0', blocks_nlog10_ff_0_1_0, '0']
- [blocks_complex_to_mag_squared_0_2, '0', blocks_nlog10_ff_0_2, '0']
- [blocks_complex_to_mag_squared_0_2_0, '0', blocks_nlog10_ff_0_2_0, '0']
- [blocks_complex_to_mag_squared_0_3, '0', blocks_nlog10_ff_0_3, '0']
- [blocks_nlog10_ff_0, '0', blocks_threshold_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_freq_sink_x_0_0_2, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_nlog10_ff_0_0_0, '0', blocks_threshold_ff_0_0_0, '0']
- [blocks_nlog10_ff_0_1, '0', blocks_threshold_ff_0_1, '0']
- [blocks_nlog10_ff_0_1_0, '0', blocks_threshold_ff_0_1_0, '0']
- [blocks_nlog10_ff_0_2, '0', blocks_threshold_ff_0_2, '0']
- [blocks_nlog10_ff_0_2_0, '0', blocks_threshold_ff_0_2_0, '0']
- [blocks_nlog10_ff_0_3, '0', blocks_threshold_ff_0_3, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', fft_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', fft_vxx_0_1, '0']
- [blocks_stream_to_vector_0_1_0, '0', fft_vxx_0_1_0, '0']
- [blocks_stream_to_vector_0_2, '0', fft_vxx_0_2, '0']
- [blocks_stream_to_vector_0_2_0, '0', fft_vxx_0_2_0, '0']
- [blocks_stream_to_vector_0_3, '0', fft_vxx_0_3, '0']
- [blocks_stream_to_vector_1, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_1_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_stream_to_vector_1_0_0, '0', qtgui_vector_sink_f_0_0_0, '0']
- [blocks_stream_to_vector_1_1, '0', qtgui_vector_sink_f_0_1, '0']
- [blocks_stream_to_vector_1_1_0, '0', qtgui_vector_sink_f_0_1_0, '0']
- [blocks_stream_to_vector_1_2, '0', qtgui_vector_sink_f_0_2, '0']
- [blocks_stream_to_vector_1_2_0, '0', qtgui_vector_sink_f_0_2_0, '0']
- [blocks_stream_to_vector_1_3, '0', qtgui_vector_sink_f_0_3, '0']
- [blocks_threshold_ff_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_threshold_ff_0, '0', epy_block_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_stream_to_vector_1_0, '0']
- [blocks_threshold_ff_0_0, '0', epy_block_0, '1']
- [blocks_threshold_ff_0_0_0, '0', blocks_stream_to_vector_1_0_0, '0']
- [blocks_threshold_ff_0_0_0, '0', epy_block_0, '5']
- [blocks_threshold_ff_0_1, '0', blocks_stream_to_vector_1_1, '0']
- [blocks_threshold_ff_0_1, '0', epy_block_0, '2']
- [blocks_threshold_ff_0_1_0, '0', blocks_stream_to_vector_1_1_0, '0']
- [blocks_threshold_ff_0_1_0, '0', epy_block_0, '6']
- [blocks_threshold_ff_0_2, '0', blocks_stream_to_vector_1_2, '0']
- [blocks_threshold_ff_0_2, '0', epy_block_0, '3']
- [blocks_threshold_ff_0_2_0, '0', blocks_stream_to_vector_1_2_0, '0']
- [blocks_threshold_ff_0_2_0, '0', epy_block_0, '7']
- [blocks_threshold_ff_0_3, '0', blocks_stream_to_vector_1_3, '0']
- [blocks_threshold_ff_0_3, '0', epy_block_0, '4']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_complex_to_mag_squared_0_0_0, '0']
- [blocks_vector_to_stream_0_1, '0', blocks_complex_to_mag_squared_0_1, '0']
- [blocks_vector_to_stream_0_1_0, '0', blocks_complex_to_mag_squared_0_1_0, '0']
- [blocks_vector_to_stream_0_2, '0', blocks_complex_to_mag_squared_0_2, '0']
- [blocks_vector_to_stream_0_2_0, '0', blocks_complex_to_mag_squared_0_2_0, '0']
- [blocks_vector_to_stream_0_3, '0', blocks_complex_to_mag_squared_0_3, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [fft_vxx_0_0_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [fft_vxx_0_1, '0', blocks_vector_to_stream_0_1, '0']
- [fft_vxx_0_1_0, '0', blocks_vector_to_stream_0_1_0, '0']
- [fft_vxx_0_2, '0', blocks_vector_to_stream_0_2, '0']
- [fft_vxx_0_2_0, '0', blocks_vector_to_stream_0_2_0, '0']
- [fft_vxx_0_3, '0', blocks_vector_to_stream_0_3, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_stream_to_vector_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', blocks_stream_to_vector_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', blocks_stream_to_vector_0_1_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', blocks_stream_to_vector_0_2, '0']
- [freq_xlating_fir_filter_xxx_0_0_1_0, '0', blocks_stream_to_vector_0_2_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_2, '0', blocks_stream_to_vector_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', blocks_stream_to_vector_0_3, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_1, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_1_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_2, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_1, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_1, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
