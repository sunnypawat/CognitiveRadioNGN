options:
  parameters:
    author: ngn
    generate_options: qt_gui
    id: walkie_transmitter
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '446006250'
  states: {}
- name: channel_freq
  id: variable
  parameters:
    value: center_freq + channel_selector * 12500
  states: {}
- name: channel_selector
  id: variable_qtgui_chooser
  parameters:
    labels: '["Channel 0", "Channel 1", "Channel 2", "Channel 3", "Channel 4", "Channel 5", "Channel 6", "Channel 7"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    type: raw
    value: '0'
  states: {}
- name: freqm
  id: variable_qtgui_range
  parameters:
    label: Freq (Hz)
    start: '446006250'
    step: '12500'
    stop: 446006250 + 7*12500
    value: '446006250'
  states: {state: disabled}
- name: lpf_decim
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0.5'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {state: disabled}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: int(samp_rate /10)
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/ngn/mario.wav
    repeat: 'True'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass channel_selector(gr.sync_block):\n    \"\"\"\n    A GNU Radio block for selecting the farthest free channel based on binary input states\n    and dynamically sending the center frequency via message passing.\n    \"\"\"\n    def __init__(self, base_freq=2.4e9, channel_spacing=1e6):\n        \"\"\"\n        Initialize the block with base frequency and channel spacing.\n\n        Args:\n        - base_freq: The base frequency for channel 0.\n        - channel_spacing: The frequency spacing between adjacent channels.\n        \"\"\"\n        gr.sync_block.__init__(self,\n            name=\"channel_selector\",\n            in_sig=None, #[(np.float32, 8)],  # Input: 8-channel binary states\n            out_sig=None\n        )       # Output: Selected channel index (0-7 or -1)\n\n        self.base_freq = base_freq\n        self.channel_spacing = channel_spacing\n\n        # Declare a message output port for sending frequency updates\n        self.message_port_register_out(pmt.intern(\"freq_update\"))\n\n    def find_farthest_free_channel(self, state):\n        \"\"\"\n        Finds the farthest free channel from all occupied ones.\n        - state: A binary array of length 8 representing the channel states.\n        - Returns the index of the farthest free channel, or -1 if no channels are free.\n        \"\"\"\n        free_indices = np.where(state == 0)[0]\n        occupied_indices = np.where(state == 1)[0]\n\n        if len(free_indices) == 0:\n            return -1  # No free channels\n\n        # Calculate distances from each free channel to the nearest occupied channel\n        distances = [\n            min(abs(free_idx - occ_idx) for occ_idx in occupied_indices) if len(occupied_indices) > 0 else 8\n            for free_idx in free_indices\n        ]\n        farthest_free_idx = free_indices[np.argmax(distances)]\n        return farthest_free_idx\n\n    def send_center_freq_message(self, channel_index):\n        \"\"\"\n        Sends a message with the center frequency based on the selected channel index.\n        \"\"\"\n        if channel_index == -1:\n            freq = None  # No valid channel selected\n        else:\n            freq = self.base_freq + channel_index * self.channel_spacing\n\n        # Create a PMT pair with the key and value\n        msg = pmt.cons(pmt.intern(\"center_freq\"), pmt.from_double(freq if freq is not None else 0))\n        self.message_port_pub(pmt.intern(\"freq_update\"), msg)\n\n    def work(self, output_items):\n        \"\"\"\n        Process incoming data and output the selected channel index.\n        \"\"\"\n        X = [1,0,0,0,0,0,0,0]  # Input data: shape (N, 8) for N samples of 8 channels\n        output = []\n\n        for row in X:\n            selected_channel = self.find_farthest_free_channel(row)\n            self.send_center_freq_message(selected_channel)  # Send frequency message\n            print(\"HEREEEEEEEEE\", selected_channel)\n            output.append(selected_channel)\n\n        output_items[0][:] = output\n        return len(output_items[0])\n\nchannel_selector = channel_selector()\nchannel_selector.work([0,0,0,0,0,0,0,0])\n\n"
    base_freq: center_freq
    channel_spacing: '12500'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, period=60, input_length=1, rate=44100)  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Finite State Machine',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self._samples_per_cycle = int(period * rate)
              self._zeros_left = self._samples_per_cycle - input_length
              self._input_length = input_length
              self._input_left = input_length
              self._state = 0     
         
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: '1.0'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: lpf_decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: channel_freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '2'
    type: ccc
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: channel_freq
    gain0: '0.8'
    gain_type0: normalized
    samp_rate: samp_rate * 0.95
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: channel_freq
    dev_addr: ''
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [analog_nbfm_rx_0, '0', audio_sink_0, '0']
- [analog_nbfm_tx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_nbfm_tx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [analog_nbfm_tx_0, '0', uhd_usrp_sink_0, '0']
- [audio_source_0, '0', analog_nbfm_tx_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_nbfm_rx_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
