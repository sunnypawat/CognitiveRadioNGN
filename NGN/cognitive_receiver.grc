options:
  parameters:
    generate_options: qt_gui
    id: receiver
    output_language: python
    title: Cognitive Radio Reciever
  states: {}

blocks:
- name: audio_0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: audio_2
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: audio_3
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: audio_4
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: audio_5
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: audio_6
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: audio_7
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: audio_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.8'
  states: {}
- name: audio_r
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: central_freq
  id: variable
  parameters:
    value: '446006250'
  states: {}
- name: ch_freq
  id: variable
  parameters:
    value: '446006000'
  states: {}
- name: ch_space
  id: variable
  parameters:
    value: 12.5e3
  states: {}
- name: low_pass_tap
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '5000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: r_samp
  id: variable
  parameters:
    value: 480e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1200000'
  states: {}
- name: threshold
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: analog_agc3_xx_1
  id: analog_agc3_xx
  parameters:
    attack_rate: '0.1'
    decay_rate: '0.01'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '700'
    type: complex
  states: {state: disabled}
- name: analog_agc3_xx_1_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '0.1'
    decay_rate: '0.01'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '700'
    type: complex
  states: {state: disabled}
- name: analog_agc3_xx_1_0_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '0.1'
    decay_rate: '0.01'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '700'
    type: complex
  states: {}
- name: analog_agc3_xx_1_0_0_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '0.1'
    decay_rate: '0.01'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '700'
    type: complex
  states: {}
- name: analog_agc3_xx_1_0_0_0_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '0.1'
    decay_rate: '0.01'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '700'
    type: complex
  states: {}
- name: analog_agc3_xx_1_0_0_0_0_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '0.1'
    decay_rate: '0.01'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '700'
    type: complex
  states: {}
- name: analog_agc3_xx_1_0_0_0_0_1
  id: analog_agc3_xx
  parameters:
    attack_rate: '0.1'
    decay_rate: '0.01'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '700'
    type: complex
  states: {}
- name: analog_agc3_xx_1_0_0_0_0_1_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '0.1'
    decay_rate: '0.01'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '700'
    type: complex
  states: {}
- name: analog_agc3_xx_1_0_0_0_1
  id: analog_agc3_xx
  parameters:
    attack_rate: '0.1'
    decay_rate: '0.01'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '700'
    type: complex
  states: {}
- name: analog_agc3_xx_1_0_0_0_2
  id: analog_agc3_xx
  parameters:
    attack_rate: '0.1'
    decay_rate: '0.01'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '700'
    type: complex
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {state: disabled}
- name: analog_nbfm_rx_0_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {state: disabled}
- name: analog_nbfm_rx_0_0_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0_0_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0_0_0_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0_0_0_0_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0_0_0_0_1
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0_0_0_0_1_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0_0_0_1
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_rx_0_0_0_0_2
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-audio_0'
    type: complex
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-threshold'
    type: complex
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-audio_3'
    type: complex
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_0_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-audio_7'
    type: complex
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_0_0_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-audio_7'
    type: complex
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_0_0_1
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-audio_3'
    type: complex
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_0_1
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-audio_5'
    type: complex
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_0_1_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-audio_5'
    type: complex
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_0_2
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-audio_1'
    type: complex
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_1
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-audio_2'
    type: complex
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_1_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-audio_6'
    type: complex
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_1_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-audio_6'
    type: complex
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_1_1
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-audio_2'
    type: complex
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_2
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-audio_4'
    type: complex
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_2_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-audio_4'
    type: complex
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_3
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-audio_0'
    type: complex
  states: {state: disabled}
- name: analog_pwr_squelch_xx_0_3_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-threshold'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_3_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-threshold'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_3_0_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-threshold'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_3_0_0_0_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-threshold'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_3_0_0_0_1
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-threshold'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_3_0_0_0_1_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-threshold'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_3_0_0_1
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-threshold'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0_3_0_0_2
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-threshold'
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: audio_r
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: audio_r
  states: {state: disabled}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    samp_rate: audio_r
  states: {}
- name: audio_sink_0_0_0_0
  id: audio_sink
  parameters:
    samp_rate: audio_r
  states: {}
- name: audio_sink_0_0_0_0_0
  id: audio_sink
  parameters:
    samp_rate: audio_r
  states: {}
- name: audio_sink_0_0_0_0_0_0
  id: audio_sink
  parameters:
    samp_rate: audio_r
  states: {}
- name: audio_sink_0_0_0_0_0_1
  id: audio_sink
  parameters:
    samp_rate: audio_r
  states: {}
- name: audio_sink_0_0_0_0_0_1_0
  id: audio_sink
  parameters:
    samp_rate: audio_r
  states: {}
- name: audio_sink_0_0_0_0_1
  id: audio_sink
  parameters:
    samp_rate: audio_r
  states: {}
- name: audio_sink_0_0_0_0_2
  id: audio_sink
  parameters:
    samp_rate: audio_r
  states: {}
- name: audio_sink_0_1
  id: audio_sink
  parameters:
    samp_rate: audio_r
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '8'
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    num_inputs: '8'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-43750'
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-31250'
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-18750'
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '31250'
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (7- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (7- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (3- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_0_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (3- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-6250'
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '43750'
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_1_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (8- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_1_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (8- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_1_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (4- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_1_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (4- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '18750'
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_2_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (6- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_2_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (6- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_3
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (2- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_0_3_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (2- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '6250'
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (5- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_1_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (5- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (1- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0_2_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (1- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0_0_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0_0_2
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"channel 0"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"channel 1"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"channel 2"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"channel 4"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"channel 6"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"channel 7"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"channel 3"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"channel 5"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '2'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '2'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '2'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '2'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '2'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '2'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '2'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_0_0_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '2'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '2'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0_0_2
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '2'
    type: ccc
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '446050000'
    gain0: '0.8'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: ch_freq
    gain0: '0.8'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: ch_freq
    gain0: '0.8'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_agc3_xx_1, '0', analog_nbfm_rx_0, '0']
- [analog_agc3_xx_1_0, '0', analog_nbfm_rx_0_0, '0']
- [analog_agc3_xx_1_0_0, '0', analog_nbfm_rx_0_0_0, '0']
- [analog_agc3_xx_1_0_0_0, '0', analog_nbfm_rx_0_0_0_0, '0']
- [analog_agc3_xx_1_0_0_0_0, '0', analog_nbfm_rx_0_0_0_0_0, '0']
- [analog_agc3_xx_1_0_0_0_0_0, '0', analog_nbfm_rx_0_0_0_0_0_0, '0']
- [analog_agc3_xx_1_0_0_0_0_1, '0', analog_nbfm_rx_0_0_0_0_0_1, '0']
- [analog_agc3_xx_1_0_0_0_0_1_0, '0', analog_nbfm_rx_0_0_0_0_0_1_0, '0']
- [analog_agc3_xx_1_0_0_0_1, '0', analog_nbfm_rx_0_0_0_0_1, '0']
- [analog_agc3_xx_1_0_0_0_2, '0', analog_nbfm_rx_0_0_0_0_2, '0']
- [analog_nbfm_rx_0, '0', audio_sink_0, '0']
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_nbfm_rx_0_0, '0', audio_sink_0_0, '0']
- [analog_nbfm_rx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_nbfm_rx_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [analog_nbfm_rx_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [analog_nbfm_rx_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0_0, '0']
- [analog_nbfm_rx_0_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_0, '0']
- [analog_nbfm_rx_0_0_0_0_0_1, '0', blocks_multiply_const_vxx_0_0_0_0_0_1, '0']
- [analog_nbfm_rx_0_0_0_0_0_1_0, '0', blocks_multiply_const_vxx_0_0_0_0_0_1_0, '0']
- [analog_nbfm_rx_0_0_0_0_1, '0', blocks_multiply_const_vxx_0_0_0_0_1, '0']
- [analog_nbfm_rx_0_0_0_0_2, '0', blocks_multiply_const_vxx_0_0_0_0_2, '0']
- [analog_pwr_squelch_xx_0, '0', blocks_add_xx_0, '0']
- [analog_pwr_squelch_xx_0_0, '0', blocks_add_xx_0, '1']
- [analog_pwr_squelch_xx_0_0_0, '0', blocks_add_xx_0, '3']
- [analog_pwr_squelch_xx_0_0_0, '0', blocks_add_xx_0_0, '3']
- [analog_pwr_squelch_xx_0_0_0_0, '0', blocks_add_xx_0, '7']
- [analog_pwr_squelch_xx_0_0_0_0_0, '0', blocks_add_xx_0_1, '7']
- [analog_pwr_squelch_xx_0_0_0_1, '0', blocks_add_xx_0_0_0, '3']
- [analog_pwr_squelch_xx_0_0_0_1, '0', blocks_add_xx_0_1, '3']
- [analog_pwr_squelch_xx_0_0_1, '0', blocks_add_xx_0, '5']
- [analog_pwr_squelch_xx_0_0_1, '0', blocks_add_xx_0_0, '1']
- [analog_pwr_squelch_xx_0_0_1_0, '0', blocks_add_xx_0_1, '5']
- [analog_pwr_squelch_xx_0_0_2, '0', blocks_add_xx_0_0_0, '1']
- [analog_pwr_squelch_xx_0_0_2, '0', blocks_add_xx_0_1, '1']
- [analog_pwr_squelch_xx_0_1, '0', blocks_add_xx_0, '2']
- [analog_pwr_squelch_xx_0_1, '0', blocks_add_xx_0_0, '2']
- [analog_pwr_squelch_xx_0_1_0, '0', blocks_add_xx_0, '6']
- [analog_pwr_squelch_xx_0_1_0_0, '0', blocks_add_xx_0_1, '6']
- [analog_pwr_squelch_xx_0_1_1, '0', blocks_add_xx_0_0_0, '2']
- [analog_pwr_squelch_xx_0_1_1, '0', blocks_add_xx_0_1, '2']
- [analog_pwr_squelch_xx_0_2, '0', blocks_add_xx_0, '4']
- [analog_pwr_squelch_xx_0_2, '0', blocks_add_xx_0_0, '0']
- [analog_pwr_squelch_xx_0_2_0, '0', blocks_add_xx_0_1, '4']
- [analog_pwr_squelch_xx_0_3, '0', blocks_add_xx_0_0_0, '0']
- [analog_pwr_squelch_xx_0_3, '0', blocks_add_xx_0_1, '0']
- [analog_pwr_squelch_xx_0_3_0, '0', low_pass_filter_0_0_0, '0']
- [analog_pwr_squelch_xx_0_3_0_0, '0', low_pass_filter_0_0_0_0, '0']
- [analog_pwr_squelch_xx_0_3_0_0_0, '0', low_pass_filter_0_0_0_0_0, '0']
- [analog_pwr_squelch_xx_0_3_0_0_0_0, '0', low_pass_filter_0_0_0_0_0_0, '0']
- [analog_pwr_squelch_xx_0_3_0_0_0_1, '0', low_pass_filter_0_0_0_0_0_1, '0']
- [analog_pwr_squelch_xx_0_3_0_0_0_1_0, '0', low_pass_filter_0_0_0_0_0_1_0, '0']
- [analog_pwr_squelch_xx_0_3_0_0_1, '0', low_pass_filter_0_0_0_0_1, '0']
- [analog_pwr_squelch_xx_0_3_0_0_2, '0', low_pass_filter_0_0_0_0_2, '0']
- [blocks_add_xx_0, '0', low_pass_filter_0, '0']
- [blocks_add_xx_0_0, '0', low_pass_filter_0, '0']
- [blocks_add_xx_0_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_add_xx_0_1, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', audio_sink_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0_0, '0', audio_sink_0_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0_0_0, '0', audio_sink_0_0_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0_0_1, '0', audio_sink_0_0_0_0_0_1, '0']
- [blocks_multiply_const_vxx_0_0_0_0_0_1_0, '0', audio_sink_0_0_0_0_0_1_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0_1, '0', audio_sink_0_0_0_0_1, '0']
- [blocks_multiply_const_vxx_0_0_0_0_2, '0', audio_sink_0_0_0_0_2, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_pwr_squelch_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_pwr_squelch_xx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', analog_pwr_squelch_xx_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', blocks_add_xx_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', analog_pwr_squelch_xx_0_1_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0_0, '0', analog_pwr_squelch_xx_0_1_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0_0_0, '0', analog_pwr_squelch_xx_0_3_0_0_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_1, '0', analog_pwr_squelch_xx_0_1_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_1_0, '0', analog_pwr_squelch_xx_0_3_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', analog_pwr_squelch_xx_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', blocks_add_xx_0_0, '1']
- [freq_xlating_fir_filter_xxx_0_0_1_0, '0', analog_pwr_squelch_xx_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_1_0_0, '0', analog_pwr_squelch_xx_0_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_1_0_0_0, '0', analog_pwr_squelch_xx_0_3_0_0_0_1_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_1_1, '0', analog_pwr_squelch_xx_0_0_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_1_1_0, '0', analog_pwr_squelch_xx_0_3_0_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_2, '0', analog_pwr_squelch_xx_0_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_2, '0', blocks_add_xx_0_0, '3']
- [freq_xlating_fir_filter_xxx_0_0_2_0, '0', analog_pwr_squelch_xx_0_0_1_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_2_0_0, '0', analog_pwr_squelch_xx_0_3_0_0_2, '0']
- [freq_xlating_fir_filter_xxx_0_0_3, '0', analog_pwr_squelch_xx_0_0_2, '0']
- [freq_xlating_fir_filter_xxx_0_0_3_0, '0', analog_pwr_squelch_xx_0_3_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', analog_pwr_squelch_xx_0_2, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', blocks_add_xx_0_0, '2']
- [freq_xlating_fir_filter_xxx_0_1_0, '0', analog_pwr_squelch_xx_0_2_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0_0, '0', analog_pwr_squelch_xx_0_3_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_2, '0', analog_pwr_squelch_xx_0_3, '0']
- [freq_xlating_fir_filter_xxx_0_2_0, '0', analog_pwr_squelch_xx_0_3_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [low_pass_filter_0_0_0_0, '0', rational_resampler_xxx_0_0_0_0, '0']
- [low_pass_filter_0_0_0_0_0, '0', rational_resampler_xxx_0_0_0_0_0, '0']
- [low_pass_filter_0_0_0_0_0_0, '0', rational_resampler_xxx_0_0_0_0_0_0, '0']
- [low_pass_filter_0_0_0_0_0_1, '0', rational_resampler_xxx_0_0_0_0_0_1, '0']
- [low_pass_filter_0_0_0_0_0_1_0, '0', rational_resampler_xxx_0_0_0_0_0_1_0, '0']
- [low_pass_filter_0_0_0_0_1, '0', rational_resampler_xxx_0_0_0_0_1, '0']
- [low_pass_filter_0_0_0_0_2, '0', rational_resampler_xxx_0_0_0_0_2, '0']
- [rational_resampler_xxx_0, '0', analog_agc3_xx_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_agc3_xx_1_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', analog_agc3_xx_1_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', analog_agc3_xx_1_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_0_0, '0', analog_agc3_xx_1_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_0_0, '0', qtgui_freq_sink_x_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_0_0_0, '0', analog_agc3_xx_1_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_0_0_0, '0', qtgui_freq_sink_x_0_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_0_0_0_0_1, '0', analog_agc3_xx_1_0_0_0_0_1, '0']
- [rational_resampler_xxx_0_0_0_0_0_1, '0', qtgui_freq_sink_x_0_0_0_0_0_1, '0']
- [rational_resampler_xxx_0_0_0_0_0_1_0, '0', analog_agc3_xx_1_0_0_0_0_1_0, '0']
- [rational_resampler_xxx_0_0_0_0_0_1_0, '0', qtgui_freq_sink_x_0_0_0_0_0_1_0, '0']
- [rational_resampler_xxx_0_0_0_0_1, '0', analog_agc3_xx_1_0_0_0_1, '0']
- [rational_resampler_xxx_0_0_0_0_1, '0', qtgui_freq_sink_x_0_0_0_0_1, '0']
- [rational_resampler_xxx_0_0_0_0_2, '0', analog_agc3_xx_1_0_0_0_2, '0']
- [rational_resampler_xxx_0_0_0_0_2, '0', qtgui_freq_sink_x_0_0_0_0_2, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_1, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_1_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_2, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_1, '0']
- [uhd_usrp_source_0_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0_0, '0']
- [uhd_usrp_source_0_0, '0', freq_xlating_fir_filter_xxx_0_0_0_1, '0']
- [uhd_usrp_source_0_0, '0', freq_xlating_fir_filter_xxx_0_0_1_0_0, '0']
- [uhd_usrp_source_0_0, '0', freq_xlating_fir_filter_xxx_0_0_1_1, '0']
- [uhd_usrp_source_0_0, '0', freq_xlating_fir_filter_xxx_0_0_2_0, '0']
- [uhd_usrp_source_0_0, '0', freq_xlating_fir_filter_xxx_0_0_3, '0']
- [uhd_usrp_source_0_0, '0', freq_xlating_fir_filter_xxx_0_1_0, '0']
- [uhd_usrp_source_0_0, '0', freq_xlating_fir_filter_xxx_0_2, '0']
- [uhd_usrp_source_0_0_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0_0_0, '0']
- [uhd_usrp_source_0_0_0, '0', freq_xlating_fir_filter_xxx_0_0_0_1_0, '0']
- [uhd_usrp_source_0_0_0, '0', freq_xlating_fir_filter_xxx_0_0_1_0_0_0, '0']
- [uhd_usrp_source_0_0_0, '0', freq_xlating_fir_filter_xxx_0_0_1_1_0, '0']
- [uhd_usrp_source_0_0_0, '0', freq_xlating_fir_filter_xxx_0_0_2_0_0, '0']
- [uhd_usrp_source_0_0_0, '0', freq_xlating_fir_filter_xxx_0_0_3_0, '0']
- [uhd_usrp_source_0_0_0, '0', freq_xlating_fir_filter_xxx_0_1_0_0, '0']
- [uhd_usrp_source_0_0_0, '0', freq_xlating_fir_filter_xxx_0_2_0, '0']

metadata:
  file_format: 1
