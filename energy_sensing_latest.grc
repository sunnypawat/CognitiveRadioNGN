options:
  parameters:
    generate_options: qt_gui
    id: energy_sensing
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_r
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: audio_samp_rate_0
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: '446006250'
  states: {state: disabled}
- name: center_freq_0
  id: variable
  parameters:
    value: '446006250'
  states: {}
- name: central_freq
  id: variable
  parameters:
    value: '446006250'
  states: {}
- name: ch_freq
  id: variable
  parameters:
    value: '446006000'
  states: {}
- name: ch_space
  id: variable
  parameters:
    value: 12.5e3
  states: {}
- name: channel_freq
  id: variable
  parameters:
    value: center_freq + channel_selector * 12500
  states: {state: disabled}
- name: channel_freq_0
  id: variable
  parameters:
    value: center_freq_0 + channel_selector_0 * 12500
  states: {}
- name: channel_selector
  id: variable_qtgui_chooser
  parameters:
    labels: '["Channel 0", "Channel 1", "Channel 2", "Channel 3", "Channel 4", "Channel 5", "Channel 6", "Channel 7"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    type: raw
    value: '0'
  states: {state: disabled}
- name: channel_selector_0
  id: variable_qtgui_chooser
  parameters:
    labels: '["Channel 0", "Channel 1", "Channel 2", "Channel 3", "Channel 4", "Channel 5", "Channel 6", "Channel 7"]'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5, 6, 7]'
    type: raw
    value: '0'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.8'
  states: {}
- name: low_pass_tap
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '5000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: lpf_decim
  id: variable
  parameters:
    value: '1'
  states: {}
- name: r_samp
  id: variable
  parameters:
    value: 480e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.2e6
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '350'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(48e3)
    max_dev: 5e3
    quad_rate: int(480e3)
    tau: '75e-6'
  states: {state: disabled}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {state: disabled}
- name: analog_nbfm_tx_0_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(audio_samp_rate)
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: '"plughw:0,0"'
    samp_rate: '480000'
  states: {state: disabled}
- name: audio_source_0_0
  id: audio_source
  parameters:
    samp_rate: int(samp_rate /10)
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_2_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_3
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '100'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '100'
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '100'
  states: {}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '100'
  states: {}
- name: blocks_nlog10_ff_0_1_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '100'
  states: {}
- name: blocks_nlog10_ff_0_2
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '100'
  states: {}
- name: blocks_nlog10_ff_0_2_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '100'
  states: {}
- name: blocks_nlog10_ff_0_3
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '100'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '8'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_3
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: float
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: float
  states: {}
- name: blocks_stream_to_vector_1_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: float
  states: {}
- name: blocks_stream_to_vector_1_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: float
  states: {}
- name: blocks_stream_to_vector_1_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: float
  states: {}
- name: blocks_stream_to_vector_1_2
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: float
  states: {}
- name: blocks_stream_to_vector_1_2_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: float
  states: {}
- name: blocks_stream_to_vector_1_3
  id: blocks_stream_to_vector
  parameters:
    num_items: '2048'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: blocks_threshold_ff_0_0_0
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: blocks_threshold_ff_0_1
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: blocks_threshold_ff_0_1_0
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: blocks_threshold_ff_0_2
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: blocks_threshold_ff_0_2_0
  id: blocks_threshold_ff
  parameters:
    high: '500'
    init: '0'
    low: '500'
  states: {}
- name: blocks_threshold_ff_0_3
  id: blocks_threshold_ff
  parameters:
    high: threshold
    init: '0'
    low: threshold
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_2_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_3
  id: blocks_vector_to_stream
  parameters:
    num_items: '2048'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/ngn/Desktop/Richard Benson - I Nani (OFFICIAL AUDIO)_055850.wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport csv\nimport pmt\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n\n    def __init__(self, file_path=\"threshold_vector.csv\"):  # only default arguments here\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.float32]*8,\n            out_sig=[(np.int32,8)]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.file_path = file_path\n        self.file = open(self.file_path, 'w', newline='')\n        self.write = csv.writer(self.file)\n        self.file.write(\"Detection data\")\n        self.message_port_register_out(pmt.intern(\"out\"))\n\n    def work(self, input_items, output_items):\n       \tdata = np.array(input_items)\n       \tnp.savetxt(\"detection_result.csv\", data * 100000000, delimiter=\",\")\n       \t\n       \tres = np.zeros(8, dtype=int)\n       \tfor i in range(len(data)):\n       \t\tif np.any(data[i]):\n       \t\t\tres[i] = 1\n       \t\n       \t#Integer message\n       \t#msg = pmt.cons(pmt.PMT_NIL, pmt.from_long(index))\n       \t\n       \tmsg = pmt.init_u32vector(len(res), res)\n        self.message_port_pub(pmt.intern(\"out\"), msg)\n        output_items = res\n        #print(output_items[0])\n        return len(input_items[0])\n        \n"
    file_path: '"/home/ngn/detection_result.csv"'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import numpy as np

      class channel_selector(gr.sync_block):
          """
          A GNU Radio block for selecting the farthest free channel based on binary input states
          and dynamically sending the center frequency via message passing.
          """
          def __init__(self, base_freq=2.4e9, channel_spacing=1e6):
              """
              Initialize the block with base frequency and channel spacing.

              Args:
              - base_freq: The base frequency for channel 0.
              - channel_spacing: The frequency spacing between adjacent channels.
              """
              gr.sync_block.__init__(self,
                  name="channel_selector",
                  in_sig=[(np.int32, 8)],  # Input: 8-channel binary states
                  out_sig=None
              )

              self.base_freq = base_freq
              self.channel_spacing = channel_spacing

              # Declare a message output port for sending frequency updates
              self.message_port_register_out(pmt.intern("freq"))
              # self.message_port_register_in(pmt.intern("state"))

          def find_farthest_free_channel(self, state):
              """
              Finds the farthest free channel from all occupied ones.
              - state: A binary array of length 8 representing the channel states.
              - Returns the index of the farthest free channel, or -1 if no channels are free.
              """
              free_indices = np.where(state == 0)[0]
              occupied_indices = np.where(state == 1)[0]
              #print("free: ", free_indices)
              #print("occupied: ", occupied_indices)

              if len(free_indices) == 0:
                  return -1  # No free channels

              # Calculate distances from each free channel to the nearest occupied channel
              distances = [
                  min(abs(free_idx - occ_idx) for occ_idx in occupied_indices) if len(occupied_indices) > 0 else 8
                  for free_idx in free_indices
              ]
              farthest_free_idx = free_indices[np.argmax(distances)]
              #print(farthest_free_idx)
              return farthest_free_idx

          def send_center_freq_message(self, channel_index):
              """
              Sends a message with the center frequency based on the selected channel index.
              """
              if channel_index == -1:
                  freq = 0  # Default to 0 if no valid channel is selected
              else:
                  freq = self.base_freq + channel_index * self.channel_spacing
              

              # Create a PMT dictionary with the frequency value
              msg = pmt.make_dict()
              msg = pmt.dict_add(msg, pmt.intern("freq"), pmt.from_double(freq))
              self.message_port_pub(pmt.intern("freq"), msg)

          def work(self, input_items, output_items):
              """
              Process incoming data and select the farthest free channel.
              """
              # Assuming input_items[0] is a (N, 8) array for N samples of 8 channels
              states = input_items[0]
              print(input_items)

              #for state in states:
              #    selected_channel = self.find_farthest_free_channel(state)
              #    self.send_center_freq_message(selected_channel)
                  
              farthest_free_index = self.find_farthest_free_channel(states)
              self.send_center_freq_message(farthest_free_index)

              return len(input_items[0])
    base_freq: center_freq_0
    channel_spacing: '12500'
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import pmt
      import numpy as np

      class channel_selector(gr.sync_block):
          """
          A GNU Radio block for selecting the farthest free channel based on binary input states
          and dynamically sending the center frequency via message passing.
          """
          def __init__(self, base_freq=2.4e9, channel_spacing=1e6):
              """
              Initialize the block with base frequency and channel spacing.

              Args:
              - base_freq: The base frequency for channel 0.
              - channel_spacing: The frequency spacing between adjacent channels.
              """
              gr.sync_block.__init__(self,
                  name="binary_states",
                  in_sig=[(np.int32, 8)],  # Input: 8-channel binary states
                  out_sig=None
              )

              self.base_freq = base_freq
              self.channel_spacing = channel_spacing
              
              self.message_port_register_out(pmt.intern("freq"))

          def work(self, input_items, output_items):
              """
              Process incoming data and select the farthest free channel.
              """
              # Assuming input_items[0] is a (N, 8) array for N samples of 8 channels
              states = input_items[0]

              #for state in states:
              #   print("state", state)
                  
              #msg = pmt.cons(pmt.PMT_NIL, pmt.from_long(index))
              
              msg = pmt.make_dict()
              msg = pmt.dict_add(msg, pmt.intern("freq"), pmt.from_long(446006250+12500+12500))
              self.message_port_pub(pmt.intern("freq"), msg)

              return len(input_items[0])
    base_freq: center_freq_0
    channel_spacing: '12500'
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(2048)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(2048)
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(2048)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(2048)
  states: {}
- name: fft_vxx_0_1_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(2048)
  states: {}
- name: fft_vxx_0_2
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(2048)
  states: {}
- name: fft_vxx_0_2_0
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(2048)
  states: {}
- name: fft_vxx_0_3
  id: fft_vxx
  parameters:
    fft_size: '2048'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(2048)
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (1- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (2- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (3- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (7- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (4- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (8- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (6- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: (5- 1) * ch_space
    decim: '1'
    samp_rate: samp_rate
    taps: low_pass_tap
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"1"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"2"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"3"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"4"'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    name: '"Test"'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_4
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: ch_freq
    fftsize: '1024'
    name: '"Frequency Sink"'
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"0 T"'
    vlen: '2048'
    x_start: '445000000'
    x_step: '446000000'
    ymax: '3'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"1 T"'
    vlen: '2048'
    x_start: '445000000'
    x_step: '446000000'
    ymax: '3'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"5 T"'
    vlen: '2048'
    x_start: '445000000'
    x_step: '446000000'
    ymax: '3'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_1
  id: qtgui_vector_sink_f
  parameters:
    name: '"2 T"'
    vlen: '2048'
    x_start: '445000000'
    x_step: '446000000'
    ymax: '3'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_1_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"6 T"'
    vlen: '2048'
    x_start: '445000000'
    x_step: '446000000'
    ymax: '3'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_2
  id: qtgui_vector_sink_f
  parameters:
    name: '"3 T"'
    vlen: '2048'
    x_start: '445000000'
    x_step: '446000000'
    ymax: '3'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_2_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"7 T"'
    vlen: '2048'
    x_start: '445000000'
    x_step: '446000000'
    ymax: '3'
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0_3
  id: qtgui_vector_sink_f
  parameters:
    name: '"4 T"'
    vlen: '2048'
    x_start: '445000000'
    x_step: '446000000'
    ymax: '3'
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: ch_freq
    fftsize: '1024'
    name: '"Waterfall Sink"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq_0
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '2'
    type: ccf
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: channel_freq
    gain0: '0.8'
    gain_type0: normalized
    samp_rate: samp_rate * 0.95
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '0'
    gain0: gain
    gain_type0: normalized
    samp_rate: samp_rate * 0.95
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: ch_freq
    gain0: '0.8'
    gain_type0: normalized
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', audio_sink_0, '0']
- [analog_nbfm_tx_0, '0', qtgui_freq_sink_x_0_0_3, '0']
- [analog_nbfm_tx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [analog_nbfm_tx_0, '0', uhd_usrp_sink_0, '0']
- [analog_nbfm_tx_0_0, '0', qtgui_freq_sink_x_0_0_4, '0']
- [analog_nbfm_tx_0_0, '0', qtgui_waterfall_sink_x_0_0_0, '0']
- [analog_nbfm_tx_0_0, '0', uhd_usrp_sink_0_0, '0']
- [audio_source_0, '0', analog_nbfm_tx_0, '0']
- [audio_source_0_0, '0', analog_nbfm_tx_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_1, '0', blocks_nlog10_ff_0_1, '0']
- [blocks_complex_to_mag_squared_0_1_0, '0', blocks_nlog10_ff_0_1_0, '0']
- [blocks_complex_to_mag_squared_0_2, '0', blocks_nlog10_ff_0_2, '0']
- [blocks_complex_to_mag_squared_0_2_0, '0', blocks_nlog10_ff_0_2_0, '0']
- [blocks_complex_to_mag_squared_0_3, '0', blocks_nlog10_ff_0_3, '0']
- [blocks_nlog10_ff_0, '0', blocks_threshold_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_freq_sink_x_0_0_2, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_threshold_ff_0_0, '0']
- [blocks_nlog10_ff_0_0_0, '0', blocks_threshold_ff_0_0_0, '0']
- [blocks_nlog10_ff_0_1, '0', blocks_threshold_ff_0_1, '0']
- [blocks_nlog10_ff_0_1_0, '0', blocks_threshold_ff_0_1_0, '0']
- [blocks_nlog10_ff_0_2, '0', blocks_threshold_ff_0_2, '0']
- [blocks_nlog10_ff_0_2_0, '0', blocks_threshold_ff_0_2_0, '0']
- [blocks_nlog10_ff_0_3, '0', blocks_threshold_ff_0_3, '0']
- [blocks_selector_0, '0', rational_resampler_xxx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', fft_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', fft_vxx_0_1, '0']
- [blocks_stream_to_vector_0_1_0, '0', fft_vxx_0_1_0, '0']
- [blocks_stream_to_vector_0_2, '0', fft_vxx_0_2, '0']
- [blocks_stream_to_vector_0_2_0, '0', fft_vxx_0_2_0, '0']
- [blocks_stream_to_vector_0_3, '0', fft_vxx_0_3, '0']
- [blocks_stream_to_vector_1, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_1_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_stream_to_vector_1_0_0, '0', qtgui_vector_sink_f_0_0_0, '0']
- [blocks_stream_to_vector_1_1, '0', qtgui_vector_sink_f_0_1, '0']
- [blocks_stream_to_vector_1_1_0, '0', qtgui_vector_sink_f_0_1_0, '0']
- [blocks_stream_to_vector_1_2, '0', qtgui_vector_sink_f_0_2, '0']
- [blocks_stream_to_vector_1_2_0, '0', qtgui_vector_sink_f_0_2_0, '0']
- [blocks_stream_to_vector_1_3, '0', qtgui_vector_sink_f_0_3, '0']
- [blocks_threshold_ff_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_threshold_ff_0, '0', epy_block_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_stream_to_vector_1_0, '0']
- [blocks_threshold_ff_0_0, '0', epy_block_0, '1']
- [blocks_threshold_ff_0_0_0, '0', blocks_stream_to_vector_1_0_0, '0']
- [blocks_threshold_ff_0_0_0, '0', epy_block_0, '5']
- [blocks_threshold_ff_0_1, '0', blocks_stream_to_vector_1_1, '0']
- [blocks_threshold_ff_0_1, '0', epy_block_0, '2']
- [blocks_threshold_ff_0_1_0, '0', blocks_stream_to_vector_1_1_0, '0']
- [blocks_threshold_ff_0_1_0, '0', epy_block_0, '6']
- [blocks_threshold_ff_0_2, '0', blocks_stream_to_vector_1_2, '0']
- [blocks_threshold_ff_0_2, '0', epy_block_0, '3']
- [blocks_threshold_ff_0_2_0, '0', blocks_stream_to_vector_1_2_0, '0']
- [blocks_threshold_ff_0_2_0, '0', epy_block_0, '7']
- [blocks_threshold_ff_0_3, '0', blocks_stream_to_vector_1_3, '0']
- [blocks_threshold_ff_0_3, '0', epy_block_0, '4']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_complex_to_mag_squared_0_0_0, '0']
- [blocks_vector_to_stream_0_1, '0', blocks_complex_to_mag_squared_0_1, '0']
- [blocks_vector_to_stream_0_1_0, '0', blocks_complex_to_mag_squared_0_1_0, '0']
- [blocks_vector_to_stream_0_2, '0', blocks_complex_to_mag_squared_0_2, '0']
- [blocks_vector_to_stream_0_2_0, '0', blocks_complex_to_mag_squared_0_2_0, '0']
- [blocks_vector_to_stream_0_3, '0', blocks_complex_to_mag_squared_0_3, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0_0, '0']
- [epy_block_0, '0', epy_block_0_0, '0']
- [epy_block_0, '0', epy_block_0_0_0, '0']
- [epy_block_0, out, blocks_message_debug_0, print]
- [epy_block_0_0, freq, blocks_message_debug_0_0, print]
- [epy_block_0_0, freq, uhd_usrp_sink_0_0, command]
- [epy_block_0_0_0, freq, blocks_message_debug_0_0, print]
- [epy_block_0_0_0, freq, uhd_usrp_sink_0_0, command]
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [fft_vxx_0_0_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [fft_vxx_0_1, '0', blocks_vector_to_stream_0_1, '0']
- [fft_vxx_0_1_0, '0', blocks_vector_to_stream_0_1_0, '0']
- [fft_vxx_0_2, '0', blocks_vector_to_stream_0_2, '0']
- [fft_vxx_0_2_0, '0', blocks_vector_to_stream_0_2_0, '0']
- [fft_vxx_0_3, '0', blocks_vector_to_stream_0_3, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_selector_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_stream_to_vector_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_selector_0, '1']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', blocks_selector_0, '2']
- [freq_xlating_fir_filter_xxx_0_0_0, '0', blocks_stream_to_vector_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', blocks_selector_0, '6']
- [freq_xlating_fir_filter_xxx_0_0_0_0, '0', blocks_stream_to_vector_0_1_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', blocks_selector_0, '3']
- [freq_xlating_fir_filter_xxx_0_0_1, '0', blocks_stream_to_vector_0_2, '0']
- [freq_xlating_fir_filter_xxx_0_0_1_0, '0', blocks_selector_0, '7']
- [freq_xlating_fir_filter_xxx_0_0_1_0, '0', blocks_stream_to_vector_0_2_0, '0']
- [freq_xlating_fir_filter_xxx_0_0_2, '0', blocks_selector_0, '5']
- [freq_xlating_fir_filter_xxx_0_0_2, '0', blocks_stream_to_vector_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', blocks_selector_0, '4']
- [freq_xlating_fir_filter_xxx_0_1, '0', blocks_stream_to_vector_0_3, '0']
- [rational_resampler_xxx_0, '0', analog_nbfm_rx_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_1, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_1_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0_2, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_1, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_1, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
